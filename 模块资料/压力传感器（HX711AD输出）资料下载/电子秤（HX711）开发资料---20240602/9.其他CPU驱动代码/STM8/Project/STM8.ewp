# IAR project STM8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER; ..\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8.hex
  ILINK.IlinkOutputFile: STM8.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group user
    ../USER/: delay.c HX711.c main.c
    ../FWlib/src/: stm8s_clk.c stm8s_gpio.c stm8s_uart1.c
